# Keil uVision project 13042708.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 13042708 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\HDL;.\APP;C:\Keil_v5\C51\INC\STC
  group Source Group 1
    ./: STARTUP.A51
  group APP
    ./HDL/: misc.h misc.c
    ./APP/: main.c
  group HDL
    ./HDL/: onewire.h ds1302.c ds1302.h onewire.c
