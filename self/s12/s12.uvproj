# Keil uVision project s12.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: s12 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: E:\mdkArmkeil5\C51\INC\STC;.\HAL;.\APP
  asm include: E:\mdkArmkeil5\C51\INC\STC
  group Source Group 1
    ./: STARTUP.A51
  group APP
    ./APP/: main.c
  group HAL
    ./HAL/: iic.c onewire.c key_board.c
    ./: key_board.h
