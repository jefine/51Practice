# Keil uVision project 04button.uvproj, settings and files
target 04button (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 04button +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: e:\mdkArmkeil5\C51\INC\STC;E:\mdkArmkeil5\C51\INC;.\src
  group SRC
    ./src/: main.c
