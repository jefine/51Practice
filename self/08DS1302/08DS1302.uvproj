# Keil uVision project 08DS1302.uvproj, settings and files
target 08DS1302 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 08DS1302 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: e:\mdkArmkeil5\C51\INC;e:\mdkArmkeil5\C51\INC\STC;E:\mdkArmkeil5\C51\INC
  group Source Group 1
    ./: main.c
