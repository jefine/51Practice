# Keil uVision project demo.uvproj, settings and files
target demo (MCS-51)
  device: AT89C52 Atmel
  output: demo +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: E:\mdkArmkeil5\C51\INC\Atmel;E:\mdkArmkeil5\C51\INC
  group <virtual_root>
    ./: 
  group Source Group 1
    ./: main.c
