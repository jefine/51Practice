# Keil uVision project 07ds18b20.uvproj, settings and files
target 07ds18b20 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 07ds18b20 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: E:\mdkArmkeil5\C51\INC\Atmel;e:\mdkArmkeil5\C51\INC\STC;E:\mdkArmkeil5\C51\INC
  group Source Group 1
    ./: main.c onewire.c
