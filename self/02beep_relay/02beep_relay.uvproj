# Keil uVision project 02beep_relay.uvproj, settings and files
target 02beep_relay (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 02beep_relay +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: E:\mdkArmkeil5\C51\INC;.\src
  group SRC
    ./src/: main.c
