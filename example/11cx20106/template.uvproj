# Keil uVision project template.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: template +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: PCF8591_ADC
  c include: ..\定时器;F:\keil4\keil4\C51\INC\STC
  group Source Group 1
    ./: main.c tim.c seg.c ultrasonic.c
